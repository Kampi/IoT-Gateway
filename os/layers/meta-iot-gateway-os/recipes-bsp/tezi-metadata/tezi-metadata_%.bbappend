# SPDX-License-Identifier: MIT
# Copyright (c) 2026 Daniel Kampert

# wrapup.sh: reboot into GatewayOS after the Easy Installer has written the
# image (headless gateway, no GUI to press "Reboot")
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
